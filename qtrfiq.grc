<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>qtrfiq</value></param>
<param><key>title</key><value>qtrfiq.py</value></param>
<param><key>author</key><value>Darren Long, G0HWW</value></param>
<param><key>description</key><value>QT GUI with rigctrl, fosphor and I?Q audio input</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rig_freq</value></param>
<param><key>value</key><value>float(subprocess.check_output(['/usr/bin/rigctl', '-m', '2', 'f']).strip())</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>96000</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>rig_freq</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import subprocess</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>SetRigFreqProbe</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value></value></param>
<param><key>function_name</key><value>set_rig_freq</value></param>
<param><key>function_args</key><value>float(subprocess.check_output(['/usr/bin/rigctl','-m','2','f']).strip())</value></param>
<param><key>poll_rate</key><value>5</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>SetSampleRateProbe</value></param>
<param><key>value</key><value>1</value></param>
<param><key>block_id</key><value></value></param>
<param><key>function_name</key><value>set_samp_rate</value></param>
<param><key>function_args</key><value>self.samp_rate</value></param>
<param><key>poll_rate</key><value>20</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>device_name</key><value>hw:4,1</value></param>
<param><key>num_outputs</key><value>2</value></param>
</block>
<block>
<key>iqbalance_optimize_c</key>
<param><key>id</key><value>iqbalance_optimize_c_0</value></param>
<param><key>period</key><value>1024</value></param>
</block>
<block>
<key>iqbalance_fix_cc</key>
<param><key>id</key><value>iqbalance_fix_cc_0</value></param>
<param><key>mag</key><value>0</value></param>
<param><key>phase</key><value>0</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_1</value></param>
<param><key>type</key><value>cc</value></param>
<param><key>length</key><value>1024</value></param>
<param><key>long_form</key><value>True</value></param>
</block>
<block>
<key>fosphor_qt_sink_c</key>
<param><key>id</key><value>fosphor_qt_sink_c_0</value></param>
<param><key>freq_center</key><value>rig_freq</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>iqbalance_optimize_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iqbalance_optimize_c_0</source_block_id><sink_block_id>iqbalance_fix_cc_0</sink_block_id><source_key>iqbal_corr</source_key><sink_key>iqbal_corr</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>iqbalance_fix_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iqbalance_fix_cc_0</source_block_id><sink_block_id>dc_blocker_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_1</source_block_id><sink_block_id>fosphor_qt_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
